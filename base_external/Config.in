## base_external/Config.in
```kconfig
menu "Custom External Packages"
source "../base_external/package/aesd-assignments/Config.in"
endmenu
```
